# Autodesk Inventor part: 257-2.50
## iProperties
Created: 2007-07
Part Number: 257-2.50
Document SubType Name: Modeling
Designer: btaylor
Density: 1 g/cm^3
Author: btaylor
